# Keil uVision project exoxip_atxp032.uvprojx, settings and files
target ecoxip_atxp032 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: MIMXRT1052DVL6A NXP
  pack: NXP.MIMXRT1052_DFP.2.3.0
  cpu: IRAM(0x00000000,0x020000) IRAM2(0x20000000,0x020000) IROM(0x60000000,0x4000000) XRAM(0x20200000,0x040000) XRAM2(0x80000000,0x02000000) CPUTYPE("Cortex-M7") FPU3(SFPU) CLOCK(12000000) ELITTLE
  output: ecoxip_atxp032
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\MIMXRT105x_ECOXIP_4MB_SEC.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: CPU_MIMXRT1052DVL6A, SKIP_SYSCLK_INIT
  c misc: --diag_suppress=61,66,1296,186
  c include: drivers, drivers\..
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: RAM 0x20200000 size 0x40000
  memory RVCT7: RAM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group drivers
    ./drivers/: fsl_common.c fsl_flexspi.c fsl_gpio.c EcoXiPdrv.c EcoXiPlut.c pin_mux.c fsl_clock.c clock_config.c system_MIMXRT1052.c EcoXiPflexspiDrvExt.c
target M29W640FT (ARM-ADS)
  device: MIMXRT1052DVL6A NXP
  pack: NXP.MIMXRT1052_DFP.2.3.0
  cpu: as above
  output: M29W640FT
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: M29W640FT
  memory RVCT4: ROM 0x60000000 size 0x4000000
  memory RVCT6: ROM 0x20200000 size 0x40000
  memory RVCT7: ROM 0x80000000 size 0x2000000
  memory RVCT9: RAM 0x0 size 0x20000
  memory RVCT10: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 5.0.2
