# Keil uVision project SP29JL032H.uvproj, settings and files
target SP29JL032H_TOP Cortex-M (ARM-ADS)
  device: STM32F101RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: S29JL032H_TOP
  AfterMake: cmd.exe /C copy S29JL032H_TOP.axf ..\S29JL032H_TOP.FLM
  c flags: Optim=3
  c define: S29JL032H_TOP
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target SP29JL032H_BOT Cortex-M (ARM-ADS)
  device: STM32F101RB STMicroelectronics
  cpu: as above
  output: S29JL032H_BOT
  AfterMake: cmd.exe /C copy S29JL032H_BOT.axf ..\S29JL032H_BOT.FLM
  c flags: Optim=3
  c define: S29JL032H_BOTTOM
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
