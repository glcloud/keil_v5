# Keil uVision project S25FL128S.uvprojx, settings and files
target S25FL128S (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: flash_algo
  AfterMake: cmd.exe /C copy .\Obj\flash_algo.axf ..\S25FL128S.FLM
  c flags: Optim=3 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Device Driver
    ./: Flash_QSPI.c
target S25FL128S_V2C (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.5.1
  cpu: as above
  output: flash_algo_v2c
  AfterMake: cmd.exe /C copy .\Obj\flash_algo_v2c.axf ..\S25FL128S_V2C.FLM
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: V2C_DAPLink
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
software components: CMSIS:CORE 5.2.0
