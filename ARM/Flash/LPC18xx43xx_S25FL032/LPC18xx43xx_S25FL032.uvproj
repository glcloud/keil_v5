# Keil uVision project LPC18xx43xx_S25FL032.uvproj, settings and files
target LPC18xx43xx_S25FL032 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPC18xx43xx_S25FL032
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: S25FL032
  c misc: --diag_suppress 3017
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group SPIFI Lib
    ./: lib_lpcspifi_M3_PI.lib
target LPC18xx43xx_S25FL064 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPC18xx43xx_S25FL064
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: S25FL064
  c misc: --diag_suppress 3017
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
target LPC18xx43xx_MX25V8035F (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: LPC18xx43xx_MX25V8035F
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=1 v6LangP=1
  c define: MX25V8035F
  c misc: --diag_suppress 3017
  scatter file: .\Target.lin
  link misc: --entry 1 --diag_suppress L6305
