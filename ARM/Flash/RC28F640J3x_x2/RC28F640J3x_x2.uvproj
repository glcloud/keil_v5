# Keil uVision project RC28F640J3x_x2.uvproj, settings and files
target RC28F640J3x_x2 (ARM-ADS)
  device: LPC2210 Philips
  cpu: IRAM(0x40000000-0x40003FFF) CLOCK(60000000) CPUTYPE(ARM7TDMI)
  output: RC28F640J3x_x2
  AfterMake: cmd.exe /C copy Out\RC28F640J3x_x2.axf ..\RC28F640J3x_x2.FLX
  c flags: Optim=3
  c misc: --diag_suppress 3017
  memory RVCT9: RAM 0x40000000 size 0x4000
  scatter file: .\Target.lin
  link misc: --entry 0
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target RC28F640J3x_x2 Cortex-M (ARM-ADS)
  device: Cortex-M1 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M1")
  output: RC28F640J3x_x2
  AfterMake: cmd.exe /C copy Out\RC28F640J3x_x2.axf ..\RC28F640J3x_x2.FLM
  c flags: Optim=3
  c misc: --diag_suppress 3017
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
