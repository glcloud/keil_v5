# Keil uVision project K8P5615UQA_x2.uvproj, settings and files
target K8P5615UQA_x2 Cortex-M (ARM-ADS)
  device: Cortex-M0 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: K8P5615UQA_x2
  AfterMake: cmd.exe /C copy Out\K8P5615UQA_x2.axf ..\K8P5615UQA_x2.FLM
  c flags: Optim=4
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
