# Keil uVision project M29W640F.uvproj, settings and files
target M29W640FB (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: M29W640FB
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: M29W640FB
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target M29W640FT (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: M29W640FT
  AfterMake: cmd.exe /C copy ".\Out\%L" "..\@L.FLM"
  c flags: Optim=3
  c define: M29W640FT
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
