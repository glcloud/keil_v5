# Keil uVision project LPC5460x_MT25QL128.uvprojx, settings and files
target LPC5460x_MT25QL128 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: LPC5460x_MT25QL128
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1
  c define: MT25QL128 CPU_LPC54608J512ET180=1
  c misc: --diag_suppress=66
  c include: .\;.\devices\LPC54608;.\devices\LPC54608\drivers
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
  group Driver
    ./devices/LPC54608/drivers/: fsl_spifi.c fsl_clock.c
software components: CMSIS:CORE 5.0.0
